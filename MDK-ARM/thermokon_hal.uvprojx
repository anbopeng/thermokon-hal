# Keil uVision project thermokon_hal.uvprojx, settings and files
target thermokon_hal (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L071RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: thermokon_hal +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32L071xx
  c include: ../Core/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\common; ..\SHELL
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l071xx.s
  group Application/User/Core
    ../Core/Src/: internal_flash.c main.c gpio.c dma.c i2c.c usart.c spi.c tim.c stm32l0xx_it.c stm32l0xx_hal_msp.c tiny_sscanf.c tiny_vsnprintf.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group common
    ../common/: modbus_test.c internal_flash_test.c cli_process.c
  group shell
    ../SHELL/: app_cli.c cli_led.c shell.c UsartShell.c
software components: CMSIS:CORE 4.3.0
